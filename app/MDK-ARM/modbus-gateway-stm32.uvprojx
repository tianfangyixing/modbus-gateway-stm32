# Keil uVision project modbus-gateway-stm32.uvprojx, settings and files
target app_A (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: app_A +hex
  AfterMake: "$K\ARM\ARM_Compiler_5.06u7\Bin\fromelf.exe" --bin --output "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USER_VECT_TAB_ADDRESS,VECT_TAB_OFFSET=0x00020200U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../LWIP/App;../LWIP/Target;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/BSP/Components/lan8742;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/compat/posix;../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;../Middlewares/Third_Party/LwIP/src/include/compat/stdc;../Middlewares/Third_Party/LwIP/system/arch;../Modbus/include;../MQTT/include;../SNTP/include;../ExternalFlash/include;../MBEDTLS/App;../Middlewares/Third_Party/mbedTLS/include/mbedtls;../Middlewares/Third_Party/mbedTLS/include;../Middlewares/Third_Party/LwIP/src/apps/altcp_tls;../Middlewares/Third_Party/RTT;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../MBEDTLS/Target;../Configuration/include;../Management/include;../Middlewares/Third_Party/SystemView-4.12.0/Config;../Middlewares/Third_Party/SystemView-4.12.0/SYSVIEW;../Middlewares/Third_Party/SystemView-4.12.0/SEGGER;../Middlewares/Third_Party/SystemView-4.12.0/Sample/FreeRTOSV10;..\Boot;..\InternalFlash\include
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x08020200 size 0x5fe00
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\app_A.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: system_time.c debug_log.c watchdog.c main.c gpio.c freertos.c dma.c iwdg.c rng.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_eth.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: lwip_random.c ethernetif.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lan8742/: lan8742.c
  group Middlewares/LwIP
    ../MQTT/src/: mqtt_altcp_tls_mbedtls.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/apps/sntp/: sntp.c
    ../Middlewares/Third_Party/LwIP/src/apps/altcp_tls/: altcp_tls_mbedtls_mem.c
  group Modbus
    ../Modbus/src/: modbus_gateway_app.c modbus_rtu.c modbus_rtu_adu_pool.c modbus_tcp_server.c modbus_rtu_transaction_scheduler.c modbus_rtu_rs485_port.c modbus_collector.c modbus_collector_codec.c
  group MQTT
    ../MQTT/src/: mqtt_publisher.c
  group SNTP
    ../SNTP/src/: sntp_service.c
  group ExternalFlash
    ../ExternalFlash/src/: external_flash.c
  group Application/User/MBEDTLS/Target
    ../MBEDTLS/Target/: platform_utils.c hardware_rng.c
  group Application/User/MBEDTLS/App
    ../MBEDTLS/App/: mbedtls.c net_sockets.c
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c camellia.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c ctr_drbg.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c md.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pkparse.c pk_wrap.c platform.c platform_util.c poly1305.c rsa.c rsa_internal.c sha256.c sha512.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c version_features.c x509.c x509_crt.c
    ../Middlewares/Third_Party/mbedTLS/include/: CMakeLists.txt
  group Middlewares/SeggerRTT
    ../Middlewares/Third_Party/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Configuration
    ../Configuration/src/: configuration.c configuration_binary_codec.c configuration_service.c
  group Management
    ../Management/src/: management_frame.c management_transport.c
  group Middlewares/SystemView
    ../Middlewares/Third_Party/SystemView-4.12.0/SYSVIEW/: SEGGER_SYSVIEW.c
    ../Middlewares/Third_Party/SystemView-4.12.0/Sample/FreeRTOSV10/: SEGGER_SYSVIEW_FreeRTOS.c
    ../Middlewares/Third_Party/SystemView-4.12.0/Sample/FreeRTOSV10/Config/Cortex-M/: SEGGER_SYSVIEW_Config_FreeRTOS.c
  group Boot
    ../Boot/: boot_control.c
  group InternalFlash
    ../InternalFlash/src/: internal_flash.c
target app_B (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: app_B +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USER_VECT_TAB_ADDRESS,VECT_TAB_OFFSET=0x00080200U
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x08080200 size 0x5fe00
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\app_B.sct
software components: CMSIS:CORE 4.3.0
